<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>gr_fractional_interpolator_xx</key>
<param><key>id</key><value>gr_fractional_interpolator_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>interp_ratio</key><value>2</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>bw</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blks2_wfm_rcv</key>
<param><key>id</key><value>blks2_wfm_rcv_0</value></param>
<param><key>quad_rate</key><value>bw</value></param>
<param><key>audio_decimation</key><value>2</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_fm_deemph</key>
<param><key>id</key><value>blks2_fm_deemph_0_1</value></param>
<param><key>samp_rate</key><value>bw</value></param>
<param><key>tau</key><value>50e-6</value></param>
</block>
<block>
<key>osmosdr_source_c</key>
<param><key>id</key><value>osmosdr_source_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>tv_stick_S</value></param>
<param><key>freq0</key><value>fc</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain_mode0</key><value>1</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>if_gain0</key><value>24</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>160e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rds_bw</value></param>
<param><key>value</key><value>1.1875e3</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>tv_stick_S</value></param>
<param><key>cutoff_freq</key><value>80000</value></param>
<param><key>width</key><value>10000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>aud_vol</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>value</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>105e6</value></param>
<param><key>min</key><value>87e6</value></param>
<param><key>max</key><value>108e6</value></param>
<param><key>num_steps</key><value>210</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>bw</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>5</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-85</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>(600,400)</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_0_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>bw</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>gr_sub_xx</key>
<param><key>id</key><value>gr_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>gr_add_xx</key>
<param><key>id</key><value>gr_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_fractional_interpolator_xx</key>
<param><key>id</key><value>gr_fractional_interpolator_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>interp_ratio</key><value>bw/samp_rate</value></param>
</block>
<block>
<key>gr_fractional_interpolator_xx</key>
<param><key>id</key><value>gr_fractional_interpolator_xx_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>interp_ratio</key><value>bw/samp_rate</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>aud_vol*10</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>aud_vol*10</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>device_name</key><value>Audio Card</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>fmrds_div16_ff</key>
<param><key>id</key><value>fmrds_div16_ff_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1e15</value></param>
</block>
<block>
<key>fmrds_biphase_decoder</key>
<param><key>id</key><value>fmrds_biphase_decoder_0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>n</key><value>int(bw/rds_bw)</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>bw</value></param>
<param><key>low_cutoff_freq</key><value>23e3</value></param>
<param><key>high_cutoff_freq</key><value>53e3</value></param>
<param><key>width</key><value>3.0e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>bw</value></param>
<param><key>low_cutoff_freq</key><value>18500</value></param>
<param><key>high_cutoff_freq</key><value>19500</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>bw</value></param>
<param><key>low_cutoff_freq</key><value>57e3-3e3</value></param>
<param><key>high_cutoff_freq</key><value>57e3+3e3</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>bw</value></param>
<param><key>cutoff_freq</key><value>1.5e3</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>fmrds_diff_decoder</key>
<param><key>id</key><value>fmrds_diff_decoder_0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tv_stick_S</value></param>
<param><key>value</key><value>1064e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44.1e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>tv_stick_S/(4)</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/Volumes/Data/Users/leosam/Dropbox/Documents/Teaching/2013_mac_tc/rds_code/bits.dat</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>blks2_fm_deemph_0_1</source_block_id><sink_block_id>band_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_1</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>gr_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>gr_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>gr_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_fm_deemph_0_1</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_fm_deemph_0_1</source_block_id><sink_block_id>low_pass_filter_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_fm_deemph_0_1</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_rcv_0</source_block_id><sink_block_id>blks2_fm_deemph_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0_0</source_block_id><sink_block_id>low_pass_filter_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gr_fractional_interpolator_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fractional_interpolator_xx_0</source_block_id><sink_block_id>blks2_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>gr_fractional_interpolator_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_fm_deemph_0_1</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>fmrds_div16_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_0_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>gr_fractional_interpolator_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fmrds_biphase_decoder_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>fmrds_diff_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>fmrds_biphase_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fmrds_div16_ff_0</source_block_id><sink_block_id>fmrds_biphase_decoder_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fractional_interpolator_xx_0_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fractional_interpolator_xx_0_0_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fmrds_diff_decoder_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fmrds_diff_decoder_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
